# Repository ZeshuLiu/SX-70-Mk2

File Readme.md:

# SX-70 Mk2

## 介绍
针对SX-70 Sonnar相机的现代化改造，在保留原本机身的自动功能的情况下，提供更直接的手动控制方式，能够更加自由地进行拍摄。**安装机身控制器后手动控制更加方便** \

### 项目组成

项目中包含几个部分的硬件：

1. [相机主控板](https://github.com/ZeshuLiu/SX-70-Mk2/tree/main/Hardwares/MainController)：替换相机机头内原装的控制器，接管相机的控制。
2. [机身控制器](https://github.com/ZeshuLiu/SX-70-Mk2/tree/main/Hardwares/Body_controller)：显示当前相机工作状态并提供用于交互的按键。粘贴在机身背部，不会增加相机高度，因此大部分相机包依旧可以通用，与相机主控板连接需要[转接器](https://github.com/ZeshuLiu/SX-70-Mk2/tree/main/Fabrication/Wire2FPC)以及60mm长1.0mm间距的6pin Fpc排线。
3. [闪光灯接口](https://github.com/ZeshuLiu/SX-70-Mk2/tree/main/Hardwares/Flash_Plug)：**(还未实际测试)**，从原本的闪光灯排上引出3.5mm接口，用于外置闪光灯。
4. [机身电池](https://github.com/ZeshuLiu/SX-70-Mk2/tree/main/Hardwares/PowerBack)：**(正在开发中)**，通过相机底部的两个触点为相机供电，可以使用iType相纸进行拍摄。

### 开发

PCB部分除闪光灯接口使用嘉立创EDA外均使用KiCad8绘制，仓库提供了相应的工程和光绘(gerber)文件。

Rev1.x - Rev2.x 版本的主控使用RP2040，通过micropython编程。micropython中硬件定时器最小单位为1ms，后续考虑换用C语言获得更高定时器配置精度。

## 性能参数

相机主控可以单独使用，此时可以进行自动测光和曝光，如果需要使用B、T以及手动模式需要配备机身控制器。

**快门速度：** 1/2000s-1s，支持B门及T门 \
**自拍定时：** 3s 5s 10s （可以与T门或B门同时使用减轻机器振动的影响）\
**测光：** 目前软件仅支持600型相纸，自动测光下最低快门速度1/2s  \
**闪光同步：** 插入闪光灯后快门组速度自动变为1/30s，在手动模式下可以设置慢于1/30s的快门速度来进行填充闪光。快门速度设置为快于1/30s时将会自动调整至1/30s，机身控制器上将会显示实际使用的快门速度\

*SX70的光圈在使用闪光灯时将会根据对焦距离进行收缩，此时调整黑白轮可以控制其光圈大小。本项目依旧保留了该特点，因此在使用闪光灯时请注意对焦距离以及黑白轮的位置*

## 样片

###### 自动测光：

###### 手动曝光：

###### 闪光灯：

###### 1/1000s 快门速度：

## 硬件制造
光绘（Gerber）文件可以在[Fabrication](https://github.com/ZeshuLiu/OPSX-Sonnar/tree/main/Fabrication)文件夹中找到，必须使用0.8mm以下的PCB制造。需要使用 60mm 长 1mm间距的 6pin fpc软排线连接主板和机身控制器。

## 软件

把板子上的U+ U- GND VCC焊到usb线上，连接电脑后可以当作树莓派Pico开发板进行操作，上传代码的参见[这里（树莓派官网）](https://www.raspberrypi.com/documentation/microcontrollers/rp2040.html#raspberry-pi-pico)。 \
在将机身主控安装至机器内部之前需要将micropython固件及代码烧录至控制器中。后续可以通过机身控制器上的USB接口连接开发板并更新python代码。
将[code](https://github.com/ZeshuLiu/OPSX-Sonnar/tree/main/code)根目录中的所有python文件上传至控制器（文件夹不需要），**并且将g_main.py命名为 main.py(非常重要，只有这样才能够上电运行)** \
建议针对自己的快门适当调整代码中快门速度的值，可以使用这个[快门速度测试器](https://github.com/ZeshuLiu/ShutterSpeedCalibrator)来测试机器的快门速度，便于调整。

## 组装
> 提示：组装需要一些基本的工具：电烙铁、撬棒和镊子。 \
大多数sx70相机的螺丝都是非常特殊的1mm x 1mm 宝丽来螺丝，拆卸需要特殊的螺丝刀，可以从咸鱼买一把或者自己磨一个。 \
在操作之前推荐先浏览以下内容[Disassembly Guide](https://instantphotography.files.wordpress.com/2010/12/polaroid-sx-70-camera-repair-book.pdf) 或者 [SX70 camera 125ASA to 600ASA conversion](https://opensx70.com/tutorials/100-600-conversion/).

拆卸后对原本主板进行替换即可，如需要机身控制器则将左上角焊盘焊线引出即可通过转接板连接机身控制器。焊接FPC时建议使用含铅(低温)焊锡，否则有损伤机器FPC的风险。只需要将原本的拆掉并且替换上去即可，对于有焊接及机身拆装经验的人来说难度不高。

### 相关开源软件

1. 项目受到了[OPSX ](https://github.com/sunyitong/OPSX)和[openSX70](https://github.com/openSX70)的启发。
2. Rev1.x - Rev2.x 版本的128x32OLED屏幕代码：[micropython-adafruit-ssd1306 ](https://github.com/adafruit/micropython-adafruit-ssd1306)
3. 机身控制器按键使用的PCF8575：[micropython-pcf8575 ](https://github.com/mcauser/micropython-pcf8575)
4. Rev1.x-Rev2.x 主控使用的tsl2561光线传感器：[micropython-adafruit-tsl256](https://github.com/adafruit/micropython-adafruit-tsl2561)

## KiCad design Hardwares/MainController/rev2/opsx_x.kicad_pcb

Parts:
C1, C2, C6, C7, C8, C9, C10, C11, C12, C14: 100n; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C3, C5, C13: 1u; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C4: 0.1u; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
D1, D3, D4: 1N4148WS; D_SOD-323
D5: LED; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1, J3: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
Q1, Q2: Q_NMOS_GSD; SOT-23
Q3, Q6: Q_PMOS_GSD; SOT-23
Q4, Q5: MMBT3904; SOT-23
R1, R2: 27.4; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R3, R35: 1k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R4, R6, R9, R11, R12, R13, R15, R17, R19: 10k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R5, R10, R14, R16, R18, R20: 12k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R7, R31: 5.6k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R8, R32: 47k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R21, R22, R24: 120; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R23, R25: 100k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R26, R33: 2.7k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R34: 330; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
TP2: TestPoint; TestPoint_Pad_2.0x2.0mm
U1: RP2040; RP2040-QFN-56
U2: TLV70433DBVR; DBV0005A_N
U3: W25Q128JVS; SOIC-8_5.23x5.23mm_P1.27mm
U4: OPTICAL-TSL2561T(6P-3.8X2.6MM); TMB6-1.55-3.8X2.6MM; MPN TSL2561T
Y1: Crystal_GND2; Resonator_SMD_Murata_CSTxExxV-3Pin_3.0x1.1mm
Z1, Z2, Z3, Z4, Z5: Selector_default
sx1: sx~; sx70_i2c

Connections:
+1V1: C1.1, C2.1, C3.1, U1.23 (DVDD), U1.45 (VREG_VOUT), U1.50 (DVDD)
+3.3V: C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, R4.1, R11.1, R12.1, R34.2, U1.1 (IOVDD), U1.10 (IOVDD), U1.22 (IOVDD), U1.33 (IOVDD), U1.42 (IOVDD), U1.43 (ADC_AVDD), U1.44 (VREG_IN), U1.48 (USB_VDD), U1.49 (IOVDD), U2.3 (OUT), U3.8 (VCC), U4.1 (VDD), Z1.1, Z5.3
/FF: U1.14 (GPIO11), sx1.FF
/FF_Left: Q6.3 (D), R26.2, Z4.1
/FF_Left_Board: Z4.2, sx1.SCL
/FF_Left_MCU: R7.2, U1.18 (GPIO15)
/FT: R9.1, sx1.FT
/FT-3: R9.2, R10.1, U1.38 (GPIO26_ADC0)
/GTD-3: R5.1, R6.2, U1.2 (GPIO0)
/GTD-6: R6.1, sx1.GTD
/LED1: D5.1 (K), U1.16 (GPIO13)
/LED2: U1.15 (GPIO12)
/MOTOR: R21.2, sx1.MOTOR
/QSPI_SCLK: U1.52 (QSPI_SCLK), U3.6 (CLK)
/QSPI_SD0: U1.53 (QSPI_SD0), U3.5 (DI(IO0))
/QSPI_SD1: U1.55 (QSPI_SD1), U3.2 (DO(IO1))
/QSPI_SD2: U1.54 (QSPI_SD2), U3.3 (IO2)
/QSPI_SD3: U1.51 (QSPI_SD3), U3.7 (IO3)
/QSPI_SS: R3.2, R4.2, U1.56 (QSPI_SS), U3.1 (~CS)
/S1F: R15.1, Z2.1, sx1.S1F
/S1F-3: R15.2, R16.1, U1.4 (GPIO2)
/S1F_FPC: Q3.3 (D), R33.2, Z2.2, Z2.3, sx1.S1F_FPC
/S1F_PF_MCU: R31.2, U1.34 (GPIO22)
/S1T: R13.1, Z3.2, Z3.3, sx1.S1T
/S1T-3: R13.2, R14.1, U1.3 (GPIO1), Z3.1
/S2: U1.17 (GPIO14), sx1.S2, sx1.S2+
/S3: U1.9 (GPIO7), sx1.S3
/S5: U1.8 (GPIO6), sx1.S5
/S8: R17.1, sx1.S8
/S8-3: R17.2, R18.1, U1.6 (GPIO4)
/S9: R19.1, sx1.S9
/S9-3: R19.2, R20.1, U1.5 (GPIO3)
/SCL0: R12.2, U1.32 (GPIO21), U4.4 (SCL)
/SCL1: U1.30 (GPIO19), Z4.3
/SDA0: R11.2, U1.31 (GPIO20), U4.6 (SDA)
/SDA1: U1.29 (GPIO18), sx1.SDA
/SOL1-: D3.2 (A), Q1.3 (D), sx1.SOL1-
/SOL1_MCU: R22.1, U1.12 (GPIO9)
/SOL2-: D4.2 (A), Q2.3 (D), sx1.SOL2-
/SOL2_MCU: R24.1, U1.28 (GPIO17)
/USB_D+: R1.2, sx1.UDP (UD+)
/USB_D-: R2.2, sx1.UDN (UD-)
/VO_Left_Board: Z5.2, sx1.VO
/XIN: U1.20 (XIN), Y1.3
/XOUT: R35.1, Y1.1
/~USB_BOOT: J1.2, R3.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, J1.1, J3.1, Q1.2 (S), Q2.2 (S), Q4.2 (E), Q5.2 (E), R5.2, R10.2, R14.2, R16.2, R18.2, R20.2, R23.1, R25.1, R26.1, R33.1, TP2.1, U1.19 (TESTEN), U1.57 (GND), U2.1 (GND), U3.4 (GND), U4.2 (ADDR), U4.3 (GND), Y1.2, Z1.2, Z1.3, sx1.GND, sx1.S2-
unnamed: D5.2 (A), R34.1
unnamed: Q1.1 (G), R22.2, R23.2
unnamed: Q2.1 (G), R24.2, R25.2
unnamed: Q3.1 (G), Q4.3 (C), R32.2
unnamed: Q4.1 (B), R31.1
unnamed: Q5.1 (B), R7.1
unnamed: Q5.3 (C), Q6.1 (G), R8.2
unnamed: R21.1, U1.7 (GPIO5)
unnamed: R2.1, U1.46 (USB_DM)
unnamed: R1.1, U1.47 (USB_DP)
unnamed: R35.2, U1.21 (XOUT)
VBUS: D1.2 (A), J3.2
VCC: C4.1, D1.1 (K), D3.1 (K), D4.1 (K), Q3.2 (S), Q6.2 (S), R8.1, R32.1, U2.2 (IN), Z5.1, sx1.S1C, sx1.SOL1+, sx1.SOL2+, sx1.VCC

Notes on the sheet:
Flash
Meter0
Power
Crystal
IF Sonar: high means button got pressed ELSE : low
Controller (RP2040 )
SCL1(not sonnar)
SCL1
SDA1
SDA1(not sonnar)
USB

Board: 4 copper layers, 95.9 x 27.8 mm, 69 parts (5 on the bottom side), 59 nets.

## KiCad design Hardwares/MainController/Rev3_Normal/SX70z_Normal/SX70z_Normal.kicad_pcb

Parts:
C1, C2: DNP; C_0402_1005Metric
C3: DNP; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C4, C5: 1u; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C6, C15: 100n; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C7: 10uf; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
D1, D3, D4: 1N4148WS; D_SOD-323
D5: LED; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1, J3: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J2: Conn_01x03_Socket; PinHeader_1x03_P2.54mm_Vertical
L1: 0R; L_0402_1005Metric
Q1, Q2: Q_NMOS_GSD; SOT-23
Q5: MMBT3904; SOT-23
Q6: Q_PMOS_GSD; SOT-23
R1, R2, R3, R4, R5, R9, R11, R12, R13, R17, R19: 10k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R6: 1k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R7: 5.6k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R8: 47k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R10, R14, R18, R20: 12k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R21, R22, R24: 120; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R23, R25: 100k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R26: 3.3k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R34: 330; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
U1: AN2051-245
U3: SPX3819M5-L-3-3; SOT-23-5
U4: ESP32-PICO-D4; QFN-48-1EP_7x7mm_P0.5mm_EP5.1x5.1mm_ThermalVias
U5: OPT4001DTSR; OPT4001-DTS0008A-MFG
sx1: sx~; sx70_i2c

Connections:
+3.3V: C5.1, C6.1, C7.1, C15.1, R1.1, R2.1, R3.1, R4.2, R5.1, R11.1, R12.1, R34.2, U3.5 (OUT), U4.1 (VDDA), U4.3 (VDDA3P3), U4.4 (VDDA3P3), U4.19 (VDD3P3_RTC), U4.37 (VDD3P3_CPU), U4.43 (VDDA), U4.46 (VDDA), U5.1 (VDD), sx1.GTD
/BOOT: J1.2, U4.23 (IO0), sx1.S1T_FPC (S1T)
/EN: R4.1, U4.9 (EN)
/ESP_RX0: J2.2, U4.40 (U0RXD/IO3), sx1.FT
/ESP_TX0: J2.1, U4.41 (U0TXD/IO1), sx1.FF
/FF: R7.2, U4.12 (IO32)
/FF_Left: Q6.3 (D), R26.2, sx1.SCL
/FT: R9.1, sx1.SDA
/FT-3: R9.2, R10.1, U4.38 (IO19)
/LED1: D5.1 (K), U4.27 (IO17)
/LNA_IN: C1.1, L1.2, U4.2 (LNA_IN)
/MOTOR: R21.2, sx1.MOTOR
/S1T: R13.2, R14.1, U4.17 (IO14), sx1.S1T
/S2: U4.24 (IO4), sx1.S2+
/S3: R1.2, U4.10 (IO34), sx1.S3
/S5: R2.2, U4.11 (IO35), sx1.S5
/S8: R17.1, sx1.S8
/S8-3: R17.2, R18.1, U4.16 (IO27)
/S9: R19.1, sx1.S9
/S9-3: R19.2, R20.1, U4.15 (IO26)
/SCL0: R11.2, U4.42 (IO21), U5.5 (SCL)
/SCL1: R5.2, U4.33 (SD1), sx1.S2
/SDA0: R12.2, U4.39 (IO22), U5.8 (SDA)
/SDA1: R3.2, U4.32 (SD0), sx1.S1F_FPC
/SOL1-: D3.2 (A), Q1.3 (D), sx1.SOL1-
/SOL1_MCU: R22.1, U4.13 (IO33)
/SOL2-: D4.2 (A), Q2.3 (D), sx1.SOL2-
/SOL2_MCU: R24.1, U4.20 (IO13)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C15.2, J1.1, J2.3, J3.1, Q1.2 (S), Q2.2 (S), Q5.2 (E), R10.2, R14.2, R18.2, R20.2, R23.1, R25.1, R26.1, U3.2 (GND), U4.49 (GND), U5.2 (ADDR), U5.4 (GND), sx1.GND, sx1.S1C, sx1.S2-
unnamed: C2.1, L1.1, U1.1
unnamed: D5.2 (A), R34.1
unnamed: Q1.1 (G), R22.2, R23.2
unnamed: Q2.1 (G), R24.2, R25.2
unnamed: Q5.1 (B), R7.1
unnamed: Q5.3 (C), Q6.1 (G), R8.2
unnamed: C3.1, U3.4 (BP)
unnamed: R6.1, U3.3 (EN)
unnamed: R21.1, U4.14 (IO25)
VBUS: D1.2 (A), J3.2
VCC: C4.1, D1.1 (K), D3.1 (K), D4.1 (K), Q6.2 (S), R6.2, R8.1, R13.1, U3.1 (IN), sx1.SOL1+, sx1.SOL2+, sx1.VCC, sx1.VO

Notes on the sheet:
Meter0
Power
2.7k
IF Sonar: high means button got pressed ELSE : low
Controller (RP2040 )
IO8 on V3
IO7 on V3
INPUT ONLY
BOOT HIGH
IO20 on V3
USB

Board: 4 copper layers, 95.9 x 72.0 mm, 50 parts (1 on the bottom side), 40 nets.

## KiCad design Hardwares/PowerBack/sx70PowerPack/sx70battery.kicad_pcb

Parts:
5V+1: 5V+; SolderWirePad_1x01_SMD_5x10mm
6V+1: 6V+; SolderWirePad_1x01_SMD_1x2mm
BAT+1: BAT+; SolderWirePad_1x01_SMD_1x2mm
BAT-1: BAT-; SolderWirePad_1x01_SMD_1x2mm
Bolt1, Bolt2, Bolt3, Bolt4: M3_BOLT; MountingHole_3.2mm_M3_Pad
C1: 4.7uf; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3, C8, C13: 100nf; C_0603_1608Metric
C4: 1uf; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C5: 10uf; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C6: 22uf; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C7: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C9: 47uf; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C10: 1uf; C_0603_1608Metric
C11: 22nf; C_0603_1608Metric
C12: 2nf; C_0603_1608Metric
CHG1: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1, D6: SS34; D_SMA
D2, D3, D4, D5: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D7: 1N5819WS; D_SOD-323_HandSoldering
GND1: GND; SolderWirePad_1x01_SMD_5x10mm
GND2: GND; SolderWirePad_1x01_SMD_1x2mm
Hole1: Tripod_hole
J1: USB_C_Receptacle_PowerOnly_6P; USB_C_Receptacle_GCT_USB4125-xx-x-0190_6P_TopMnt_Horizontal
L1: 4.7uH; L_APV_APH0650
L2: 3.3uH; L_APV_APH0650
R1, R9, R13: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R3, R4, R5: 3.3k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6: 39k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8: 60.4k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10, R11: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12: 100; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R14: 866; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R15: 330k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16: 51k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R_PRG1: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
S1: SS12D07VG4; SW_SS12D07VG4; PARTREV 1
STB1: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
Sx70_Pogopin1: Sx70_Pogopin; sx_70_pogopin
U1: TP4057; SOT-23-6
U2: DW01A; SOT-23-6
U3: LN60A; SOT-23-6_Handsoldering
U4: HTSSOP-14-1EP_4.4x5mm_P0.65mm_EP3.4x5mm_Mask3x3.1mm
U5, U6, U7, U8: TSSOP-8_4.4x3mm_P0.65mm
U9: TLV61048DBVR; SOT-23-6

Connections:
+5V: 5V+1.1, C1.2, CHG1.2 (A), J1.A9 (VBUS), J1.B9 (VBUS), STB1.2 (A), U1.4 (VCC)
+6V: 6V+1.1, C5.1, C9.1, C10.1, D1.1 (K), D6.1 (K), D7.1 (K), R6.1, R15.1, Sx70_Pogopin1.1 (V+)
/BAT+: C4.1, C6.1, C7.1, C8.1, D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), L1.1, L2.1, S1.2, U3.1 (VDD), U4.3 (Vin), U4.4 (EN), U9.4 (EN), U9.5 (VIN)
/RealBat+: BAT+1.1, C2.1, R12.1, S1.1, U1.3 (BAT)
/RealBat-: BAT-1.1, C3.2, U2.6 (GND), U5.2 (S1), U5.3 (S1), U6.2 (S1), U6.3 (S1), U7.2 (S1), U7.3 (S1), U8.2 (S1), U8.3 (S1)
/SW: D1.2 (A), L1.2, U9.1 (SW)
GND: C1.1, C2.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, D7.2 (A), GND1.1, GND2.1, J1.A12 (GND), J1.B12 (GND), J1.S1 (SHIELD), R7.2, R8.2, R10.1, R11.1, R13.1, R16.2, R_PRG1.1, S1.S1 (SHIELD), S1.S2 (SHIELD), Sx70_Pogopin1.2 (V-), U1.2 (GND), U3.2 (GND), U4.6 (SYNC), U4.7 (AGND), U4.12 (PGND), U4.13 (PGND), U4.14 (PGND), U4.15 (EP), U5.6 (S2), U5.7 (S2), U6.6 (S2), U6.7 (S2), U7.6 (S2), U7.7 (S2), U8.6 (S2), U8.7 (S2), U9.2 (GND)
unnamed: C13.1, R14.2
unnamed: CHG1.1 (K), R1.2
unnamed: D2.1 (K), R2.2
unnamed: D3.1 (K), R5.2
unnamed: D4.1 (K), R4.2
unnamed: D5.1 (K), R3.2
unnamed: D6.2 (A), L2.2, U4.1 (SW), U4.2 (SW)
unnamed: J1.A5 (CC1), R11.2
unnamed: J1.B5 (CC2), R10.2
unnamed: R9.2, STB1.1 (K)
unnamed: R_PRG1.2, U1.6 (PROG)
unnamed: R1.1, U1.1 (~CHRG)
unnamed: R9.1, U1.5 (~STDBY)
unnamed: R13.2, U2.2 (CS)
unnamed: U2.3 (OC), U5.5 (G2), U6.5 (G2), U7.5 (G2), U8.5 (G2)
unnamed: U2.1 (OD), U5.4 (G1), U6.4 (G1), U7.4 (G1), U8.4 (G1)
unnamed: C3.1, R12.2, U2.5 (VCC)
unnamed: R3.1, U3.6 (D1)
unnamed: R4.1, U3.5 (D2)
unnamed: R5.1, U3.4 (D3)
unnamed: R2.1, U3.3 (D4)
unnamed: C12.1, R14.1, U4.8 (COMP)
unnamed: R6.2, R7.1, U4.9 (FB)
unnamed: R8.1, U4.10 (FREQ)
unnamed: C11.1, U4.5 (SS)
unnamed: R15.2, R16.1, U9.3 (FB)

Notes on the sheet:
电池升6V
电池升压6V-备用
USB
电池电量检测
相机供电
使用GPL-3.0许可 https://github.com/ZeshuLiu/SX-70-Mk2
测试点
电池保护
